Commit message: Adding planning to Val

File: urdf/tall_plant_multi_dof2.urdf (robot description, URDF)
Before this commit: robot origins, 3 links, 2 joints
Links:
- link plant: mass 10.0 -> 0.0
