Commit message: Removed extra code and added Val to multi world

File: models/short_floor.urdf (robot description, URDF)
Before this commit: robot flat_terrain, 1 links, 0 joints
Links:
- link base_link: mass .0 -> None
